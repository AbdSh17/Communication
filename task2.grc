options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: file_sample_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: main_sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    alias: Carrier
    amp: '1'
    comment: |-
      Carrier signal - Cos
      Frequency: 200KHz  ---  Amplitude: 1
    freq: 200e3
    offset: '0'
    phase: '0'
    samp_rate: main_sample_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: main_sample_rate
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: file_sample_rate
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: saving the transmitted signal
    file: C:\Users\Lenovo\OneDrive\Desktop\pro\Communication-main\Communication-main\modulated_signal.dat
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: |-
      Pluto only takes float value
      while we were using complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Message * Carrier
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    alias: pre_recorde
    comment: |-
      pre-recorded file with .wav extintion
      Sample Rate: 48k - sampled by an online tool
    file: C:\Users\Lenovo\OneDrive\Desktop\pro\Communication-main\Communication-main\trail_record.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_1
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: main_sample_rate
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '48000'
    comment: |-
      for printing the signal after demodulation

      note: the freq. domain ideal wave is delta (S)
      but the signal will be more like a bell shape
      due to many reasons
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '48000'
    comment: |-
      for printing the signal after demodulation

      note: the freq. domain ideal wave is delta (S)
      but the signal will be more like a bell shape
      due to many reasons
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Resample the signal from
      48K -> 1M --- ( 1M / 48K ~= 21 )
    decim: '1'
    interp: ' 21'
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_complex_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0, '0', iio_pluto_sink_1, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_0, '0', audio_sink_0_0, '0']
- [blocks_wavfile_source_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
