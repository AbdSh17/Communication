options:
  parameters:
    generate_options: qt_gui
    id: task2Demodulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: file_sample_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: main_sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      Carrier signal - Cos
      Frequency: 200KHz  ---  Amplitude: 1
    freq: 200e3
    offset: '0'
    phase: '0'
    samp_rate: main_sample_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: file_sample_rate
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: main_sample_rate
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: reciving the transmitted signal
    file: C:\Users\HP\Music\communications_project\modulated_signal.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    alias: mul
    comment: C` * S
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    alias: constant_mult
    comment: |-
      Multiply it by a constant
      to improve voice amplitude
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: main_sample_rate
    bbdc: 'False'
    buffer_size: '32768'
    comment: |-
      Pluto device
      that recive the signal
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: main_sample_rate
    type: fc32
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Low pass filter to gain the signal at origin
    cutoff_freq: '25000'
    decim: '1'
    gain: '1'
    samp_rate: main_sample_rate
    type: fir_filter_fff
    width: '600'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: file_sample_rate
    comment: |-
      for printing the signal after demodulation

      note: the freq. domain ideal wave is delta (S)
      but the signal will be more like a bell shape
      due to many reasons
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Resample the signal from
      48K -> 1M --- ( 1M / 48K ~= 21 )
    decim: '21'
    interp: ' 1'
    type: fff
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0_0, '0', rational_resampler_xxx_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', audio_sink_0_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
